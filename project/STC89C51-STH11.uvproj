# Keil uVision project STC89C51-STH11.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC89C51-STH11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51
    ../src/: main.c LCD1602.c SHT11.c alarm.c
  group INCLUDE
    ../inc/: LCD1602.h STH11.h alarm.h
