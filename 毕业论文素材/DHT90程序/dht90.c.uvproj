# Keil uVision project dht90.c.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: dht90 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/黄毛毛/51c/dht90-03/: STARTUP.A51
    ./: dht90.c
